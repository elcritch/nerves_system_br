## package/zerotier-one/Config.in
```kconfig
config BR2_PACKAGE_ZEROTIER_ONE
	bool "zerotier-one"
	help
    A Smart Ethernet Switch for Earth.

	  https://www.zerotier.com/
```
